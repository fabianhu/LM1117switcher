File: LM1117SW.sch (EAGLE design)
At the start: 10 parts

Commit message: added images
Other:
- moved on the sheet: C1, C2, L1, PAD1, PAD2, PAD3, PAD4, R1, R2
